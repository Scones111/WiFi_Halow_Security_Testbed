options:
  parameters:
    category: '[IEEE802.11AH]'
    generate_options: hb
    generator_class_name: PythonHierBlockNoGuiGenerator
    generator_module: gnuradio.grc.workflows.python_hb_nogui
    id: halow_phy_hier
    output_language: python
    title: HaLow PHY Hier
  states: {}

blocks:
- name: alpha_mcs
  id: variable
  parameters:
    value: 2**.5 if encoding == 10 else 1
  states: {}
- name: header_formatter
  id: variable
  parameters:
    value: ieee802_11ah.signal_field()
  states: {}
- name: max_symbols
  id: variable
  parameters:
    value: int(5 + 1 + ((16 + 800 * 8 + 6) * 2) / 24)
  states: {}
- name: min_plateau
  id: variable
  parameters:
    value: '2'
  states: {}
- name: occupied_carriers
  id: variable
  parameters:
    value: ((-13, -12, -11, -10, -9, -8, -6, -5, -4, -3, -2, -1, 1, 2, 3, 4, 5, 6, 8, 9, 10, 11, 12, 13),)
  states: {}
- name: pilots
  id: variable
  parameters:
    value: ((1, -1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(1, -1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(1, -1),(1, -1),(-1, 1),(1,-1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(1, -1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(1, -1),(1, -1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(1, -1),(1, -1),(-1, 1),(-1, 1),(1, -1),(1, -1),(1, -1),(1, -1),(1, -1),(1, -1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(1, -1),(1, -1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(1, -1),(1, -1),(1, -1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(1, -1),(1, -1),(1, -1),(1, -1),(-1, 1),(1, -1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(1, -1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(1, -1),(1, -1),(-1, 1),(1, -1),(1, -1),(1, -1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(1, -1),(1, -1),(1, -1),(1, -1),(-1, 1),(-1, 1),(1, -1),(1, -1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(1, -1),(-1, 1),(1, -1),(1, -1),(1, -1),(-1,1),(1, -1),(1, -1),(1, -1),(-1, 1),(-1, 1),(1, -1),(1, -1),(-1, 1),(1, -1),(1, -1),(1, -1),(1, -1),(-1, 1),(1, -1),(1, -1),(1, -1),(1, -1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(1, -1),(-1, 1),(1, -1),(-1, 1),(1, -1),(1, -1),(-1, 1),(-1, 1),(1, -1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(1, -1),(-1, 1),(1, -1),(1, -1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(1, -1),(1, -1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(1, -1),(1, -1),(1, -1),(1, -1),(1, -1),(1, -1),(1, -1),(1, -1),(-1, 1),(1, -1),(-1, 1),(1, -1),(1, -1),(1, -1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(1,-1),(1, -1),(1, -1),(-1, 1),(1, -1),(1, -1),(-1, 1),(1, -1),(1, -1),(-1, 1),(1, -1),(-1, 1),(1, -1),(-1, 1),(1, -1),(1, -1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(1, -1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(1, -1),(1, -1),(-1, 1),(1, -1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(1, -1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(1, -1),(1, -1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(1, -1),(1, -1),(-1, 1),(-1, 1),(1, -1),(1, -1),(1, -1),(1, -1),(1, -1),(1, -1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(1, -1),(1, -1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(1, -1),(1, -1),(1, -1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(1, -1),(1, -1),(1, -1),(1, -1),(-1, 1),(1, -1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(1, -1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(1, -1),(1, -1),(-1, 1),(1, -1),(1, -1),(1, -1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(1, -1),(1, -1),(1, -1),(1, -1),(-1, 1),(-1, 1),(1, -1),(1, -1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(1, -1),(-1, 1),(1, -1),(1, -1),(1, -1),(-1, 1),(1, -1),(1, -1),(1, -1),(-1, 1),(-1, 1),(1, -1),(1, -1),(-1, 1),(1, -1),(1, -1),(1, -1),(1, -1),(-1, 1),(1, -1),(1, -1),(1, -1),(1, -1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(1, -1),(-1, 1),(1, -1),(-1, 1),(1, -1),(1, -1),(-1, 1),(-1, 1),(1, -1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(1,-1),(1, -1),(-1, 1),(1, -1),(1, -1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(1, -1),(1, -1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(1, -1),(1, -1),(1, -1),(1, -1),(1, -1),(1, -1),(1, -1),(1, -1),(-1, 1),(1, -1),(-1, 1),(1, -1),(1, -1),(1, -1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(1, -1),(1, -1),(1, -1),(-1, 1),(1, -1),(1, -1),(-1, 1),(1, -1),(1, -1),(-1, 1),(1, -1),(-1, 1),(1, -1),(-1, 1),(1, -1),(1, -1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(1, -1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(1, -1),(1, -1),(-1, 1),(1, -1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(1, -1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(1, -1),(1, -1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(1, -1),(1, -1),(-1, 1),(-1, 1),(1, -1),(1, -1),(1, -1),(1, -1),(1, -1),(1, -1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(1, -1),(1, -1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(1, -1),(1, -1),(1, -1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(1, -1),(1, -1),(1, -1),(1, -1),(-1, 1),(1, -1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(1, -1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(1, -1),(1, -1),(-1, 1),(1, -1),(1, -1),(1, -1),(-1, 1),(1, -1),(-1, 1),(-1, 1),(1, -1),(1, -1),(1, -1),(1, -1),(-1, 1),(-1, 1),(1, -1),(1, -1),(1, -1),(-1, 1),(-1, 1),(-1, 1),(1, -1),(-1, 1),(1, -1),(-1, 1),(1, -1),(1,-1),(1, -1),(-1, 1),(1, -1),(1, -1),(1, -1),(-1, 1),(-1, 1),(1, -1),(1, -1),(-1, 1),(1, -1),(1, -1),(1, -1),(1, -1),(-1, 1),(1, -1),(1, -1),)
  states: {}
- name: sync_length
  id: variable
  parameters:
    value: '240'
  states: {}
- name: sync_words
  id: variable
  parameters:
    value: ((0.0, 0.0, 0.0, 0.0,  alpha_mcs * (0.849837+0.849837j), 0.0, 0.0, 0.0,  alpha_mcs * (-1.69967-1.69967j), 0.0, 0.0, 0.0,  alpha_mcs * (1.69967+1.69967j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, alpha_mcs * (-1.69967-1.69967j), 0.0, 0.0, 0.0,  alpha_mcs * (-1.69967-1.69967j), 0.0, 0.0, 0.0,  alpha_mcs * (-0.849837-0.849837j), 0.0, 0.0, 0.0),(0.0, 0.0, 0.0, 0.0,  alpha_mcs * (0.849837+0.849837j), 0.0, 0.0, 0.0,  alpha_mcs * (-1.69967-1.69967j), 0.0, 0.0, 0.0,  alpha_mcs * (1.69967+1.69967j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0,  alpha_mcs * (-1.69967-1.69967j), 0.0,0.0, 0.0,  alpha_mcs * (-1.69967-1.69967j), 0.0, 0.0, 0.0,  alpha_mcs * (-0.849837-0.849837j), 0.0, 0.0, 0.0),(0.0, 0.0, 0.0, 0.0,  alpha_mcs * (0.849837+0.849837j), 0.0, 0.0, 0.0,  alpha_mcs * (-1.69967-1.69967j), 0.0, 0.0, 0.0,  alpha_mcs * (1.69967+1.69967j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0,  alpha_mcs * (-1.69967-1.69967j), 0.0, 0.0, 0.0,  alpha_mcs * (-1.69967-1.69967j), 0.0, 0.0, 0.0,  alpha_mcs * (-0.849837-0.849837j), 0.0, 0.0, 0.0),(0.0, 0.0, 0.0, 0.0,  alpha_mcs * (0.849837+0.849837j), 0.0, 0.0, 0.0,  alpha_mcs * (-1.69967-1.69967j), 0.0, 0.0, 0.0,  alpha_mcs * (1.69967+1.69967j), 0.0, 0.0, 0.0, 0.0, 0.0, 0.0, 0.0,  alpha_mcs * (-1.69967-1.69967j), 0.0, 0.0, 0.0,  alpha_mcs * (-1.69967-1.69967j), 0.0, 0.0, 0.0,  alpha_mcs * (-0.849837-0.849837j), 0.0, 0.0, 0.0),(0+0j, 0+0j, 0+0j, -1.83697e-16+1j, -1-2.44929e-16j, 3.06162e-16-1j, 1+3.67394e-16j, 4.28626e-16-1j, 1+4.89859e-16j, -5.51091e-16+1j, -1-6.12323e-16j, -2.44991e-15+1j, -1-7.34788e-16j, -9.80336e-16-1j, -1-8.57253e-16j, -2.69484e-15+1j, 0+0j, 7.35407e-16+1j, 1+1.10218e-15j, 2.93977e-15-1j, 1+1.22465e-15j, 4.90478e-16+1j, 1+4.89983e-15j, 3.1847e-15-1j, 1+1.46958e-15j, 2.45548e-16+1j, -1+1.96067e-15j, -3.42963e-15+1j, 1+1.71451e-15j, 6.18981e-19+1j, 0+0j, 0+0j),(0, 0, 0, 1, -1, 1, -1, -1, 1, -1, 1, 1, -1, 1, 1, 1, 0, -1, -1, -1, 1, -1, -1, -1, 1, -1, 1, 1, 1, -1, 0, 0),(0, 0, 0, 1, -1, 1, -1, -1, 1, -1, 1, 1, -1, 1, 1, 1, 0, -1, -1, -1, 1, -1, -1, -1, 1, -1, 1, 1, 1, -1, 0, 0),(0, 0, 0, 1, -1, 1, -1, -1, 1, -1, 1, 1, -1, 1, 1, 1, 0, -1, -1, -1, 1, -1, -1, -1, 1, -1, 1, 1, 1, -1, 0, 0))
  states: {}
- name: bandwidth
  id: parameter
  parameters:
    type: eng_float
    value: 1e6
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: sync_length-min_plateau
    type: complex
  states: {}
- name: blocks_delay_0_0
  id: blocks_delay
  parameters:
    delay: '8'
    type: complex
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: chunks_post_mapper
    type: complex
  states: {state: disabled}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: '24'
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_moving_average_xx_1
  id: blocks_moving_average_xx
  parameters:
    length: '40'
    max_iter: '4000'
    scale: '1'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '32'
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    minoutbuf: max_symbols * 24 * 8
    ninputs: '2'
    tag_preserve_head_pos: '1'
    type: complex
  states: {}
- name: chan_est
  id: parameter
  parameters:
    value: ieee802_11ah.LS
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    minoutbuf: max_symbols * 24 * 8 * 2
    out_type: complex
    symbol_table: '[-1, 1]'
  states: {}
- name: digital_ofdm_carrier_allocator_cvc_0_0_0
  id: digital_ofdm_carrier_allocator_cvc
  parameters:
    fft_len: '32'
    len_tag_key: '"packet_len"'
    minoutbuf: max_symbols * 24 * 8
    occupied_carriers: ((-13, -12, -11, -10, -9, -8, -6, -5, -4, -3, -2, -1, 1, 2, 3, 4, 5, 6, 8, 9, 10, 11, 12, 13),)
    output_is_shifted: 'True'
    pilot_carriers: (( -7, 7,), )
    pilot_symbols: pilots
    sync_words: sync_words
  states: {}
- name: digital_ofdm_cyclic_prefixer_0_0
  id: digital_ofdm_cyclic_prefixer
  parameters:
    cp_len: '8'
    input_size: '32'
    minoutbuf: max_symbols * 24 * 8 * 10
    rolloff: '2'
    tagname: '"packet_len"'
  states: {}
- name: digital_packet_headergenerator_bb_0
  id: digital_packet_headergenerator_bb
  parameters:
    header_formatter: header_formatter.formatter()
    len_tag_key: '"packet_len"'
  states: {}
- name: encoding
  id: parameter
  parameters:
    value: ieee802_11ah.BPSK_1_2
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: '32'
    forward: 'False'
    minoutbuf: max_symbols * 24 * 8
    shift: 'True'
    type: complex
    window: tuple([1/26**.5] * 32)
  states: {}
- name: fft_vxx_0_1
  id: fft_vxx
  parameters:
    fft_size: '32'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.rectangular(32)
  states: {}
- name: frequency
  id: parameter
  parameters:
    type: eng_float
    value: 917e6
  states: {}
- name: ieee802_11ah_chunks_to_symbols_xx_0
  id: ieee802_11ah_chunks_to_symbols_xx
  parameters:
    minoutbuf: max_symbols * 24 * 8
  states: {}
- name: ieee802_11ah_decode_mac_0
  id: ieee802_11ah_decode_mac
  parameters:
    debug: 'False'
    log: 'False'
  states: {}
- name: ieee802_11ah_frame_equalizer_0
  id: ieee802_11ah_frame_equalizer
  parameters:
    algo: chan_est
    bw: bandwidth
    debug: 'False'
    freq: frequency
    log: 'False'
  states: {}
- name: ieee802_11ah_mapper_0
  id: ieee802_11ah_mapper
  parameters:
    debug: 'False'
    encoding: encoding
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: samp_out
    type: complex
  states: {}
- name: pad_sink_1
  id: pad_sink
  parameters:
    label: carrier
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_2
  id: pad_sink
  parameters:
    label: mac_out
    optional: 'True'
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: samp_in
    type: complex
  states: {}
- name: pad_source_1
  id: pad_source
  parameters:
    label: mac_in
    optional: 'True'
    type: message
  states: {}
- name: sensitivity
  id: parameter
  parameters:
    type: eng_float
    value: '0.56'
  states: {}
- name: sync_long
  id: ieee802_11ah_sync_long
  parameters:
    debug: 'False'
    log: 'False'
    sync_length: sync_length-min_plateau
  states: {}
- name: sync_short
  id: ieee802_11ah_sync_short
  parameters:
    debug: 'False'
    log: 'False'
    min_plateau: min_plateau
    threshold: sensitivity
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_moving_average_xx_1, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', sync_long, '1']
- [blocks_delay_0_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_delay_0_0, '0', sync_short, '0']
- [blocks_divide_xx_0, '0', sync_short, '2']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_moving_average_xx_0, '0', sync_short, '1']
- [blocks_moving_average_xx_1, '0', blocks_divide_xx_0, '1']
- [blocks_multiply_xx_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0_1, '0']
- [blocks_tagged_stream_mux_0, '0', digital_ofdm_carrier_allocator_cvc_0_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_tagged_stream_mux_0, '0']
- [digital_ofdm_carrier_allocator_cvc_0_0_0, '0', fft_vxx_0_0, '0']
- [digital_ofdm_cyclic_prefixer_0_0, '0', pad_sink_0, '0']
- [digital_packet_headergenerator_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [fft_vxx_0_0, '0', digital_ofdm_cyclic_prefixer_0_0, '0']
- [fft_vxx_0_1, '0', ieee802_11ah_frame_equalizer_0, '0']
- [ieee802_11ah_chunks_to_symbols_xx_0, '0', blocks_file_sink_0, '0']
- [ieee802_11ah_chunks_to_symbols_xx_0, '0', blocks_tagged_stream_mux_0, '1']
- [ieee802_11ah_decode_mac_0, out, pad_sink_2, in]
- [ieee802_11ah_frame_equalizer_0, '0', ieee802_11ah_decode_mac_0, '0']
- [ieee802_11ah_frame_equalizer_0, symbols, pad_sink_1, in]
- [ieee802_11ah_mapper_0, '0', digital_packet_headergenerator_bb_0, '0']
- [ieee802_11ah_mapper_0, '0', ieee802_11ah_chunks_to_symbols_xx_0, '0']
- [pad_source_0, '0', blocks_complex_to_mag_squared_0, '0']
- [pad_source_0, '0', blocks_delay_0_0, '0']
- [pad_source_0, '0', blocks_multiply_xx_0, '0']
- [pad_source_1, out, ieee802_11ah_mapper_0, in]
- [sync_long, '0', blocks_stream_to_vector_0, '0']
- [sync_short, '0', blocks_delay_0, '0']
- [sync_short, '0', sync_long, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
